# Keil uVision project sample.uvprojx, settings and files
target ms9601_ms933_ms8006 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HW32L003F8 XMC
  pack: XMC.HW32L003_DFP.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sample +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ms8006\HW32L003_HAL_Driver\Inc\;ms8006\CMSIS\Device\XMC\HW32L003\Include\;ms8006\CMSIS\Include\;ms8006\BSP\header\;.\SDK\inc;.\ms9601
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CX32L0xx_HAL_Driver
    ./ms8006/CMSIS/Device/XMC/HW32L003/Source/ARM/: startup_HW32l003.s
    ./ms8006/CMSIS/Device/XMC/HW32L003/Source/: system_HW32l003.c
    ./ms8006/HW32L003_HAL_Driver/Src/: HW32l003_hal_gpio.c HW32l003_hal_uart.c HW32l003_hal_flash.c HW32l003_hal.c
  group mculib
    ./ms8006/BSP/source/: mculib_gpio.c mculib_uart.c mculib_timer.c mculib_key.c mculib_peripheral.c mculib_i2c.c mculib_iap.c mculib_user_setting.c
  group app
    ./: main.c
    ./ms9601/: hdmi.c
  group SDK
    ./SDK/: ms933x_sdklib_keil_m0_vxxx_202xxxxx.lib
